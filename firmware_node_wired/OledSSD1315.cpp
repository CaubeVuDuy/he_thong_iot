#include "OledSSD1315.h"
#include <pgmspace.h>
#include <string.h>

// Bảng font 5x7 cho mã ASCII 0x20..0x7E (mỗi ký tự 5 cột, LSB ở trên)
static const uint8_t FONT5X7[] PROGMEM = {
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x20 ' '
    0x00, 0x00, 0x5F, 0x00, 0x00, // 0x21 '!'
    0x00, 0x07, 0x00, 0x07, 0x00, // 0x22 '"'
    0x14, 0x7F, 0x14, 0x7F, 0x14, // 0x23 '#'
    0x24, 0x2A, 0x7F, 0x2A, 0x12, // 0x24 '$'
    0x23, 0x13, 0x08, 0x64, 0x62, // 0x25 '%'
    0x36, 0x49, 0x55, 0x22, 0x50, // 0x26 '&'
    0x00, 0x05, 0x03, 0x00, 0x00, // 0x27 '''
    0x00, 0x1C, 0x22, 0x41, 0x00, // 0x28 '('
    0x00, 0x41, 0x22, 0x1C, 0x00, // 0x29 ')'
    0x14, 0x08, 0x3E, 0x08, 0x14, // 0x2A '*'
    0x08, 0x08, 0x3E, 0x08, 0x08, // 0x2B '+'
    0x00, 0x50, 0x30, 0x00, 0x00, // 0x2C ','
    0x08, 0x08, 0x08, 0x08, 0x08, // 0x2D '-'
    0x00, 0x60, 0x60, 0x00, 0x00, // 0x2E '.'
    0x20, 0x10, 0x08, 0x04, 0x02, // 0x2F '/'
    0x3E, 0x51, 0x49, 0x45, 0x3E, // 0x30 '0'
    0x00, 0x42, 0x7F, 0x40, 0x00, // 0x31 '1'
    0x42, 0x61, 0x51, 0x49, 0x46, // 0x32 '2'
    0x21, 0x41, 0x45, 0x4B, 0x31, // 0x33 '3'
    0x18, 0x14, 0x12, 0x7F, 0x10, // 0x34 '4'
    0x27, 0x45, 0x45, 0x45, 0x39, // 0x35 '5'
    0x3C, 0x4A, 0x49, 0x49, 0x30, // 0x36 '6'
    0x01, 0x71, 0x09, 0x05, 0x03, // 0x37 '7'
    0x36, 0x49, 0x49, 0x49, 0x36, // 0x38 '8'
    0x06, 0x49, 0x49, 0x29, 0x1E, // 0x39 '9'
    0x00, 0x36, 0x36, 0x00, 0x00, // 0x3A ':'
    0x00, 0x56, 0x36, 0x00, 0x00, // 0x3B ';'
    0x08, 0x14, 0x22, 0x41, 0x00, // 0x3C '<'
    0x14, 0x14, 0x14, 0x14, 0x14, // 0x3D '='
    0x00, 0x41, 0x22, 0x14, 0x08, // 0x3E '>'
    0x02, 0x01, 0x51, 0x09, 0x06, // 0x3F '?'
    0x32, 0x49, 0x79, 0x41, 0x3E, // 0x40 '@'
    0x7E, 0x11, 0x11, 0x11, 0x7E, // 0x41 'A'
    0x7F, 0x49, 0x49, 0x49, 0x36, // 0x42 'B'
    0x3E, 0x41, 0x41, 0x41, 0x22, // 0x43 'C'
    0x7F, 0x41, 0x41, 0x22, 0x1C, // 0x44 'D'
    0x7F, 0x49, 0x49, 0x49, 0x41, // 0x45 'E'
    0x7F, 0x09, 0x09, 0x09, 0x01, // 0x46 'F'
    0x3E, 0x41, 0x49, 0x49, 0x7A, // 0x47 'G'
    0x7F, 0x08, 0x08, 0x08, 0x7F, // 0x48 'H'
    0x00, 0x41, 0x7F, 0x41, 0x00, // 0x49 'I'
    0x20, 0x40, 0x41, 0x3F, 0x01, // 0x4A 'J'
    0x7F, 0x08, 0x14, 0x22, 0x41, // 0x4B 'K'
    0x7F, 0x40, 0x40, 0x40, 0x40, // 0x4C 'L'
    0x7F, 0x02, 0x0C, 0x02, 0x7F, // 0x4D 'M'
    0x7F, 0x04, 0x08, 0x10, 0x7F, // 0x4E 'N'
    0x3E, 0x41, 0x41, 0x41, 0x3E, // 0x4F 'O'
    0x7F, 0x09, 0x09, 0x09, 0x06, // 0x50 'P'
    0x3E, 0x41, 0x51, 0x21, 0x5E, // 0x51 'Q'
    0x7F, 0x09, 0x19, 0x29, 0x46, // 0x52 'R'
    0x46, 0x49, 0x49, 0x49, 0x31, // 0x53 'S'
    0x01, 0x01, 0x7F, 0x01, 0x01, // 0x54 'T'
    0x3F, 0x40, 0x40, 0x40, 0x3F, // 0x55 'U'
    0x1F, 0x20, 0x40, 0x20, 0x1F, // 0x56 'V'
    0x3F, 0x40, 0x38, 0x40, 0x3F, // 0x57 'W'
    0x63, 0x14, 0x08, 0x14, 0x63, // 0x58 'X'
    0x07, 0x08, 0x70, 0x08, 0x07, // 0x59 'Y'
    0x61, 0x51, 0x49, 0x45, 0x43, // 0x5A 'Z'
    0x00, 0x7F, 0x41, 0x41, 0x00, // 0x5B '['
    0x02, 0x04, 0x08, 0x10, 0x20, // 0x5C '\'
    0x00, 0x41, 0x41, 0x7F, 0x00, // 0x5D ']'
    0x04, 0x02, 0x01, 0x02, 0x04, // 0x5E '^'
    0x40, 0x40, 0x40, 0x40, 0x40, // 0x5F '_'
    0x00, 0x01, 0x02, 0x04, 0x00, // 0x60 '`'
    0x20, 0x54, 0x54, 0x54, 0x78, // 0x61 'a'
    0x7F, 0x48, 0x44, 0x44, 0x38, // 0x62 'b'
    0x38, 0x44, 0x44, 0x44, 0x20, // 0x63 'c'
    0x38, 0x44, 0x44, 0x48, 0x7F, // 0x64 'd'
    0x38, 0x54, 0x54, 0x54, 0x18, // 0x65 'e'
    0x08, 0x7E, 0x09, 0x01, 0x02, // 0x66 'f'
    0x0C, 0x52, 0x52, 0x52, 0x3E, // 0x67 'g'
    0x7F, 0x08, 0x04, 0x04, 0x78, // 0x68 'h'
    0x00, 0x44, 0x7D, 0x40, 0x00, // 0x69 'i'
    0x20, 0x40, 0x44, 0x3D, 0x00, // 0x6A 'j'
    0x7F, 0x10, 0x28, 0x44, 0x00, // 0x6B 'k'
    0x00, 0x41, 0x7F, 0x40, 0x00, // 0x6C 'l'
    0x7C, 0x04, 0x18, 0x04, 0x78, // 0x6D 'm'
    0x7C, 0x08, 0x04, 0x04, 0x78, // 0x6E 'n'
    0x38, 0x44, 0x44, 0x44, 0x38, // 0x6F 'o'
    0x7C, 0x14, 0x14, 0x14, 0x08, // 0x70 'p'
    0x08, 0x14, 0x14, 0x18, 0x7C, // 0x71 'q'
    0x7C, 0x08, 0x04, 0x04, 0x08, // 0x72 'r'
    0x48, 0x54, 0x54, 0x54, 0x20, // 0x73 's'
    0x04, 0x3F, 0x44, 0x40, 0x20, // 0x74 't'
    0x3C, 0x40, 0x40, 0x20, 0x7C, // 0x75 'u'
    0x1C, 0x20, 0x40, 0x20, 0x1C, // 0x76 'v'
    0x3C, 0x40, 0x30, 0x40, 0x3C, // 0x77 'w'
    0x44, 0x28, 0x10, 0x28, 0x44, // 0x78 'x'
    0x0C, 0x50, 0x50, 0x50, 0x3C, // 0x79 'y'
    0x44, 0x64, 0x54, 0x4C, 0x44, // 0x7A 'z'
    0x00, 0x08, 0x36, 0x41, 0x00, // 0x7B '{'
    0x00, 0x00, 0x7F, 0x00, 0x00, // 0x7C '|'
    0x00, 0x41, 0x36, 0x08, 0x00, // 0x7D '}'
    0x10, 0x08, 0x08, 0x10, 0x08  // 0x7E '~'
};

// Chuỗi khởi tạo chuẩn cho SSD1315 (tương thích ngược SSD1306)
static const uint8_t INIT_CMDS[] = {
    0xAE,       // Display OFF
    0xD5, 0x80, // Clock divide ratio
    0xA8, 0x3F, // Multiplex ratio 1/64
    0xD3, 0x00, // Display offset 0
    0x40,       // Start line 0
    0xAD, 0x30, // SSD1315 Internal IREF Enable
    0x8D, 0x14, // Charge Pump Enable
    0x20, 0x00, // Horizontal Addressing Mode
    0xA1,       // Segment re-map
    0xC8,       // COM output scan direction
    0xDA, 0x12, // COM pins config (128x64)
    0x81, 0xFF, // Contrast tối đa cho chữ sáng rõ
    0xD9, 0xF1, // Pre-charge period
    0xDB, 0x30, // VCOMH deselect level tối ưu cho SSD1315
    0xA4,       // Resume RAM display
    0xA6,       // Normal display
    0x2E,       // Deactivate scroll
    0xAF        // Display ON
};

OledSSD1315::OledSSD1315() : _wire(&Wire), _addr(0x3C), _ready(false) {
    memset(_buffer, 0, sizeof(_buffer));
}

bool OledSSD1315::probeAddress(uint8_t addr) {
    _wire->beginTransmission(addr);
    return (_wire->endTransmission() == 0);
}

bool OledSSD1315::sendCommand(uint8_t cmd) {
    _wire->beginTransmission(_addr);
    _wire->write(0x00);
    _wire->write(cmd);
    return (_wire->endTransmission() == 0);
}

bool OledSSD1315::sendCommandList(const uint8_t *cmds, size_t len) {
    for (size_t i = 0; i < len; i++) {
        if (!sendCommand(cmds[i])) return false;
    }
    return true;
}

bool OledSSD1315::begin(TwoWire &wirePort) {
    _wire = &wirePort;
    if (probeAddress(0x3C)) {
        _addr = 0x3C;
    } else if (probeAddress(0x3D)) {
        _addr = 0x3D;
    } else {
        _ready = false;
        return false;
    }

    _ready = sendCommandList(INIT_CMDS, sizeof(INIT_CMDS));
    if (_ready) {
        clear();
        display();
    }
    return _ready;
}

void OledSSD1315::clear() {
    memset(_buffer, 0, sizeof(_buffer));
}

void OledSSD1315::drawPixel(int16_t x, int16_t y, bool on) {
    if (x < 0 || x >= OLED_WIDTH || y < 0 || y >= OLED_HEIGHT) return;
    uint16_t idx = (uint16_t)x + ((uint16_t)y / 8) * OLED_WIDTH;
    uint8_t bit = 1 << (y & 7);
    if (on) _buffer[idx] |= bit;
    else _buffer[idx] &= ~bit;
}

void OledSSD1315::drawHLine(int16_t x, int16_t y, int16_t w) {
    for (int16_t i = 0; i < w; i++) drawPixel(x + i, y, true);
}

void OledSSD1315::drawChar(int16_t x, int16_t y, char c, uint8_t scale) {
    if (c < 0x20 || c > 0x7E) c = '?';
    if (scale == 0) scale = 1;
    uint16_t offset = (uint16_t)(c - 0x20) * 5;

    for (uint8_t col = 0; col < 5; col++) {
        uint8_t line = pgm_read_byte(&FONT5X7[offset + col]);
        for (uint8_t row = 0; row < 7; row++) {
            if (line & (1 << row)) {
                for (uint8_t sx = 0; sx < scale; sx++) {
                    for (uint8_t sy = 0; sy < scale; sy++) {
                        drawPixel(x + col * scale + sx, y + row * scale + sy, true);
                    }
                }
            }
        }
    }
}

void OledSSD1315::drawText(int16_t x, int16_t y, const char *str, uint8_t scale) {
    if (!str) return;
    if (scale == 0) scale = 1;
    int16_t cx = x;
    while (*str) {
        drawChar(cx, y, *str++, scale);
        cx += 6 * scale;
    }
}

void OledSSD1315::drawTextCentered(int16_t y, const char *str, uint8_t scale) {
    if (!str) return;
    if (scale == 0) scale = 1;
    int16_t len = (int16_t)strlen(str);
    if (len == 0) return;
    int16_t totalW = len * 6 * scale - scale;
    int16_t startX = (OLED_WIDTH - totalW) / 2;
    if (startX < 0) startX = 0;
    drawText(startX, y, str, scale);
}

bool OledSSD1315::display() {
    if (!_ready) return false;

    static const uint8_t WIN_CMDS[] = {
        0x21, 0x00, 0x7F, // Column 0..127
        0x22, 0x00, 0x07  // Page 0..7
    };
    if (!sendCommandList(WIN_CMDS, sizeof(WIN_CMDS))) {
        _ready = false;
        return false;
    }

    // Gửi từng gói 16 byte để không tràn bộ đệm I2C 128 byte của ESP32 Wire
    for (uint16_t i = 0; i < OLED_BUF_SIZE; i += 16) {
        _wire->beginTransmission(_addr);
        _wire->write(0x40);
        _wire->write(&_buffer[i], 16);
        if (_wire->endTransmission() != 0) {
            _ready = false;
            return false;
        }
    }
    return true;
}

